# Keil uVision project hawk_devkit_3_0_cms_bootloader_i2c.uvprojx, settings and files
target BAT32A239 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BAT32A239KK64FB Cmsemicon
  pack: Cmsemicon.BAT32A239.1.0.3
  cpu: IRAM(0x20000000,0x08000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hawk_devkit_3_0_cms_bootloader_i2c +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HW_TELM_USING_IIC
  c include: ..\..\..\Driver\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000300 size 0x7d00
  group Source
    ../: main.c bootloader.c protocol.c
  group Driver
    ../../../Driver/src/: sci.c sci_user.c flash.c flash_user.c clk.c
    ../: bsp_basic.c bsp_telematic.c
software components: CMSIS:CORE 5.4.0, Device:ISR 1.0.0, Device:Startup 1.0.0
