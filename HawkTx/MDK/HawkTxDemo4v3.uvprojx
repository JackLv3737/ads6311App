# Keil uVision project HawkTxDemo4v3.uvprojx, settings and files
target BAT32A239 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BAT32A239KK64FB Cmsemicon
  pack: Cmsemicon.BAT32A239.1.0.3
  cpu: IRAM(0x20000000,0x08000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hawk_devkit3v0_cms +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: ..\..\tools\firmware_tools\app_info_gen.exe --app $L@L.bin --out  $Lapp_info.hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_DEMO4,BOARD_DEMO4_V3
  c include: ..\..\Driver\inc;..\..\Bsp;..\..\HawkTx;..\..\Adaps;..\..\Bsp\cm_backtrace;..\..\Common;..\..\Middlewares\USMART;..\..\Middlewares\BMI270
  memory RVCT4: ROM 0x5000 size 0x3b000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\scatter.map
  group App
    ../: main.c tx_app.c
    ../../Bsp/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group Driver
    ../../Driver/src/: dma.c sci.c sci_user.c adc.c adc_user.c flash.c flash_user.c gpio.c tim4.c tim4_user.c tim8.c tim8_user.c intp.c dac.c timm.c timm_user.c clk.c
  group Bsp
    ../../Bsp/: bsp_stub.c bsp_adc.c bsp_basic.c bsp_gpio.c bsp_i2c.c bsp_pwm.c bsp_spi.c bsp_telematic.c bsp_timer.c bsp_dac.c bsp_upgrade.c bsp_nvram.c bsp_clkout.c
    ../../Bsp/cm_backtrace/: cm_backtrace.c
  group Adaps
    ../../Adaps/: adaps_nst112_dirver.c adaps_pid.c adaps_pmic_driver.c adaps_soc_protocol.c adaps_ina201_driver.c adaps_rx_temprature.c adaps_tx_switch.c adaps_dv8001_driver.c adaps_flash_driver.c adaps_imu.c
  group Usmart
    ../../Middlewares/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group Common
    ../../Common/: ring_buf.c
  group Bmi270
    ../../Middlewares/BMI270/: bmi2.c bmi270.c bmi270_context.c
software components: CMSIS:CORE 5.4.0, Device:ISR 1.0.0, Device:Startup 1.0.0
